// link_vote.hpp — «проверенное» чтение регистров ядра ПЛИС по LINK (прошивка 0.1.168, 24.11.2026).
//
// ЗАЧЕМ. Обычное чтение по LINK (tang::read → link_spi3::transfer) ничем не защищено: у обмена нет
// ни контрольной суммы, ни повтора, ни счётчика ошибок. Слово может прийти неверным по двум
// причинам:
//   1) на проводе — помеха или край тайминга QSPI. В tang_link.cpp записано: в 0.1.70 на 40 МГц
//      проскакивала одна ошибка примерно на 6000 обменов, хотя проверка из 1000 кругов прошла чисто;
//   2) внутри ядра. Ведомый LINK ядра (fb_link.sv и его копии в других ядрах) берёт значение
//      регистра из домена тактов ядра «как есть», без синхронизации. Домен тактов — это часть схемы,
//      которая работает от одного тактового сигнала; переход значения из одного домена в другой
//      называют CDC (clock domain crossing). Если значение меняется ровно в момент выдачи, часть
//      битов приходит от старого значения, часть — от нового: слово «рвётся». Комментарий в
//      fb_link.sv так и говорит: «счётчик, пойманный посреди смены, ESP прочитает повторно».
// Контрольная сумма на проводе вторую причину не поймала бы: ядро посчитало бы её уже от рваного
// слова. Повторное чтение ловит обе причины.
//
// КАК. Те же слова читаются два раза подряд.
//   - Все слова совпали — значение надёжно: два независимых чтения дали одно и то же.
//   - Не совпали — третье чтение, и каждое слово берётся как медиана трёх: то значение, которое
//     окажется посередине, если три числа выстроить по возрастанию.
//
// ПОЧЕМУ МЕДИАНА, а не «читать, пока два чтения не совпадут». Есть регистры, которые меняются сами,
// без участия ESP: например, FIFO_FREE очереди команд ядра Quake 2 растёт всё время, пока ядро
// разбирает очередь. Между двумя чтениями такой счётчик успевает измениться, и совпадения можно не
// дождаться никогда. Медиана трёх работает и для таких регистров:
//   - ни одно чтение не испорчено — медиана равна одному из трёх настоящих значений;
//   - испорчено одно чтение — медиана не меньше меньшего и не больше большего из двух целых чтений.
//     Испорченное слово-выброс уходит в край ряда и отбрасывается.
//   Пример со счётчиком: прочитано 100, 0x858, 102 → по порядку 100, 102, 0x858 → медиана 102.
//   Пример с постоянным регистром: 7, 0x8007, 7 → по порядку 7, 7, 0x8007 → медиана 7.
// Чего медиана не спасает: испорчены два чтения из трёх (это квадрат и без того редкого события);
// или слово с набором флагов меняется само и в то же время испорчено одно чтение — тогда медиана
// окажется числом между двумя настоящими, но не обязательно одним из них.
//
// ЦЕНА. Два обмена вместо одного, если слово не менялось, и три, если менялось или испортилось.
// На плате разработчика LINK работает на 26,7 МГц, и чтение 16 слов длится около 26 мкс (строка
// «LINK throughput» в журнале ESP при запуске; частоту ESP выбирает сама). Поэтому проверенное чтение — для регистров состояния (FIFO_FREE,
// STATUS), а не для потоков данных (звук, сектора), где цена удвоилась бы.
//
// Файл не зависит от ESP-IDF: ту же логику собирает и проверяет стенд на ПК
// (tests/link_vote_host.cpp).
#pragma once

#include <stddef.h>
#include <stdint.h>
#include <string.h>

namespace zifi {
namespace link_vote {

// Больше слов за одно чтение LINK не бывает: буфер данных контроллера SPI3 — 64 байта (16 слов).
constexpr size_t kMaxWords = 16;

// Медиана трёх чисел. Сначала из a и b берутся меньшее (low) и большее (high), потом c «зажимается»
// между ними: c меньше low — посередине оказался бы low; c больше high — high; иначе посередине само c.
inline uint32_t median3(uint32_t a, uint32_t b, uint32_t c) {
  const uint32_t low = a < b ? a : b;
  const uint32_t high = a < b ? b : a;
  if (c < low) {
    return low;
  }
  if (c > high) {
    return high;
  }
  return c;
}

// Чем кончилось проверенное чтение.
enum class Outcome {
  kFailed,   // обмен не прошёл (LINK не готов, транзакция не закончилась) — words не тронуты
  kAgreed,   // два чтения совпали
  kMedian,   // понадобилось третье чтение, слова — медианы
};

// Выброс (0.1.169, для счётчика в команде консоли «tang»): в трёх чтениях одного слова два
// совпали, а третье от них отличается. У постоянного регистра это прямо испорченное чтение.
// У счётчика, который меняется сам, все три чтения обычно разные, и испорченное среди них
// не отличить от настоящей смены — такие случаи выбросом не считаются (счётчик выбросов
// поэтому показывает не все ошибки, а только заведомые).
struct Outlier {
  bool found = false;      // хоть одно слово с выбросом
  size_t index = 0;        // номер первого такого слова в блоке (0…count-1)
  uint32_t rejected = 0;   // отброшенное значение — то, что прочитано неверно
  uint32_t accepted = 0;   // принятое — то, что совпало в двух других чтениях
};

// Проверенное чтение count слов (1…16) в words.
// read(out) — одно обычное чтение тех же count слов в буфер out; возвращает false, если обмен не
// прошёл. Это шаблон, а не указатель на функцию: одну и ту же логику зовут и прошивка (настоящее
// чтение по SPI3, tang::readChecked), и стенд на ПК (подставные чтения с заранее заданными ошибками).
// outlier (можно nullptr) — первый выброс, если понадобилось третье чтение и он нашёлся.
template <typename Read>
Outcome readVoted(Read&& read, uint32_t* words, size_t count, Outlier* outlier = nullptr) {
  if (outlier != nullptr) {
    *outlier = Outlier{};
  }
  if (words == nullptr || count == 0 || count > kMaxWords) {
    return Outcome::kFailed;
  }
  uint32_t first[kMaxWords];
  uint32_t second[kMaxWords];
  if (!read(first) || !read(second)) {
    return Outcome::kFailed;
  }
  if (memcmp(first, second, count * sizeof(uint32_t)) == 0) {
    memcpy(words, second, count * sizeof(uint32_t));
    return Outcome::kAgreed;
  }
  uint32_t third[kMaxWords];
  if (!read(third)) {
    return Outcome::kFailed;
  }
  // Каждое слово — отдельно: в блоке могут меняться одни слова и стоять на месте другие.
  for (size_t i = 0; i < count; ++i) {
    const uint32_t a = first[i];
    const uint32_t b = second[i];
    const uint32_t c = third[i];
    words[i] = median3(a, b, c);
    // Выброс: ровно два чтения из трёх равны. Медиана тогда и есть это общее значение,
    // а третье — отброшенное.
    if (outlier != nullptr && !outlier->found && (a == b || a == c || b == c) && !(a == b && b == c)) {
      outlier->found = true;
      outlier->index = i;
      outlier->accepted = words[i];
      outlier->rejected = a == b ? c : (a == c ? b : a);
    }
  }
  return Outcome::kMedian;
}

}  // namespace link_vote
}  // namespace zifi
